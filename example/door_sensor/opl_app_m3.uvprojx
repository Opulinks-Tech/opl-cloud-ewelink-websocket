# Keil uVision project opl_app_m3.uvprojx, settings and files
target OPL1000_APP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl_app_m3 +hex
  AfterMake: .\opl_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>"
  c misc: --preinclude=sys_common.h
  c include: ..\..\opl_sdk\SDK\APS\apps\le_app\cmd_app;..\..\opl_sdk\SDK\APS\apps\le_app\mtc_app;..\..\opl_sdk\SDK\APS\apps\le_app\pts_app;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_auxadc;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_dbg_uart;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_dma;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_i2c;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_patch;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_pwm;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_spi;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_system;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_tick;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_tmr;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_uart;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_vic;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\hal_wdt;..\..\opl_sdk\SDK\APS\driver\chip\opl1000\securityipdriver;..\..\opl_sdk\SDK\APS\driver\CMSIS\Include;..\..\opl_sdk\SDK\APS\driver\CMSIS\Device\opl1000\Include;..\..\opl_sdk\SDK\APS\FreeRtos\Source\include;..\..\opl_sdk\SDK\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\opl_sdk\SDK\APS\middleware\netlink\at;..\..\opl_sdk\SDK\APS\middleware\netlink\ble_controller_layer\inc;..\..\opl_sdk\SDK\APS\middleware\netlink\cli;..\..\opl_sdk\SDK\APS\middleware\netlink\common\sys_api;..\..\opl_sdk\SDK\APS\middleware\netlink\common\sys_api\rom_if;..\..\opl_sdk\SDK\APS\middleware\netlink\common\sys_ctrl;..\..\opl_sdk\SDK\APS\middleware\netlink\controller_task;..\..\opl_sdk\SDK\APS\middleware\netlink\data_flow;..\..\opl_sdk\SDK\APS\middleware\netlink\diag_task;..\..\opl_sdk\SDK\APS\middleware\netlink\le_stack;..\..\opl_sdk\SDK\APS\middleware\netlink\msg;..\..\opl_sdk\SDK\APS\middleware\netlink\mw_fim;..\..\opl_sdk\SDK\APS\middleware\netlink\mw_ota;..\..\opl_sdk\SDK\APS\middleware\netlink\ps_task;..\..\opl_sdk\SDK\APS\middleware\netlink\wifi_controller_layer;..\..\opl_sdk\SDK\APS\middleware\netlink\wifi_controller_layer\rom_if;..\..\opl_sdk\SDK\APS\middleware\netlink\wifi_mac;..\..\opl_sdk\SDK\APS\middleware\third_party\lwip-2.0.3\;..\..\opl_sdk\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\opl_sdk\SDK\APS\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\opl_sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\opl_sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\opl_sdk\SDK\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\opl_sdk\SDK\APS\middleware\third_party\mbedtls\include;..\..\opl_sdk\SDK\APS\middleware\third_party\mbedtls\configs;..\..\opl_sdk\SDK\APS\middleware\third_party\mbedtls\port\include;..\..\opl_sdk\SDK\APS\middleware\third_party\tinycrypt\include;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\opl_sdk\SDK\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\opl_sdk\SDK\APS\project\common;..\..\opl_sdk\SDK\APS\project\opl1000\boot_sequence;..\..\opl_sdk\SDK\APS\project\opl1000\include;..\..\opl_sdk\SDK\APS\project\opl1000\startup;..\..\opl_sdk\SDK\APS_PATCH\apps\le_app\include;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_auxadc;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_dbg_uart;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_system;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_uart;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\opl_sdk\SDK\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\opl_sdk\SDK\APS_PATCH\FreeRtos\Source;..\..\opl_sdk\SDK\APS_PATCH\FreeRtos\Source\include;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\at;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\cli;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\common\sys_api;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\controller_task;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\data_flow;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\diag_task;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\le_stack\patch;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\msg;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\mw_fim;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\ps_task;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\opl_sdk\SDK\APS_PATCH\middleware\netlink\wifi_mac;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\httpclient;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\opl_sdk\SDK\APS_PATCH\project\opl1000\include;..\..\opl_sdk\SDK\APS_PATCH\project\opl1000\startup;.\main;.\main\hal;.\main\handle;..\..\blewifi_mgr;..\..\cloud;.\main\sensor;.\main\btn_press_ctrl;.\main\common;.\main\infra_cjson;..\..\opl_sdk\SDK\APS_PATCH\middleware\third_party\httpclient;..\..\cloud\ssl_client
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
  group main
    ./main/: app_at_cmd.c app_ctrl.c app_main.c
  group hal
    ./main/hal/: hal_os_patch.c main_patch.c mw_fim_default_group11_project.c mw_fim_default_group12_project.c mw_fim_default_group16_project.c mw_fim_default_group17_project.c
  group handle
    ./main/handle/: blewifi_handle.c iot_handle.c
  group object
    ../../opl_sdk/SDK/APS/targets/opl1000/object/: symdefs.o
    ../../opl_sdk/SDK/APS/targets/opl1000/Output/Objects/: opl1000_patch_m3.lib opl1000_patch_m3_lite.lib opl1000_sdk_m3.lib opl1000_sdk_m3_lite.lib
  group blewifi_mgr
    ../../blewifi_mgr/: blewifi_ble_api.c blewifi_ble_FSM.c blewifi_common.c blewifi_data.c blewifi_server_app.c blewifi_server_app_gatt.c blewifi_wifi_api.c blewifi_wifi_FSM.c ssidpwd_proc.c
  group iot_data
    ../../cloud/: iot_data.c iot_ota_http.c iot_rb_data.c
  group cloud
    ../../cloud/: cloud_http.c coolkit_websocket.c
  group sensor
    ./main/sensor/: sensor_battery.c sensor_common.c sensor_door.c
  group btn_press_ctrl
    ./main/btn_press_ctrl/: btn_press_ctrl.c
  group infra_cJSON
    ./main/infra_cjson/: infra_cjson.c
  group ssl_client
    ../../cloud/ssl_client/: ssl_client.c
  group httpclient
    ../../opl_sdk/SDK/APS_PATCH/middleware/third_party/httpclient/: httpclient.c
target OPL1000_Sonoff (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: as above
  output: opl_app_m3_sonoff +hex
  AfterMake: .\opl_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL1000_APS __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ __SONOFF__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>"
  c misc: --preinclude=sys_common.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl_app_m3.sct
  link misc: --datacompressor off --entry=__Patch_EntryPoint
